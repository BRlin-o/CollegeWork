# Keil uVision project Project_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Project_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 AT89X52.H TABLE8.H work2.c
